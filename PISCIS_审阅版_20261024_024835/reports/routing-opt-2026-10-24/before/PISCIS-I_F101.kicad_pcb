# Repository The-Cabbage/PISCIS-I_E-Piano-Project

File README.md:

# PISCIS-I 项目入口

PISCIS 是面向碎片化演奏、旋律即兴与声音探索的掌上数字乐器，采用双手握持、双拇指演奏。当前产品定义以[产品需求文档](运营与开发策略/PISCIS_1.0_PRD_2026-10-20.md)为准；本页只维护项目状态摘要和入口。

## 当前状态

截至 2026-10-20，按工作区资料判断：处于**技术可行性与 MVP 探索阶段**，已有多套子板设计、机械模型和浏览器音色交互原型；这些资料不等同于整机验证完成。

- **主要目标**：收敛可复现的演奏样机链路，明确键盘、主板、音源和结构的集成边界。
- **MVP 范围**：尚未单独冻结，待在当前任务中明确验证切片和通过条件。PRD 第 4 节的 P0 是首代交付范围，摘要为独立演奏、核心交互、EP-1/EO-1、卡片管理、更新救援、可检修结构及基础接口文档；不直接把全部 P0 当成本轮 MVP。
- **关键限制**：主控与资源、供电音频、键盘机械参数和量化验收指标仍有待决项，详见 PRD 第 12、14 节；现有工程分支各有适用范围，不能混用规格。
- **当前开发重点（建议顺序）**：先确认本轮样机采用的工程组合，再处理霍尔键盘稳定触发与对接验证；具体状态只在 [BACKLOG](BACKLOG.md) 更新。

## 文档入口

| 要找什么 | 唯一维护位置 / 入口 |
| --- | --- |
| 当前任务、问题与随手想法 | [BACKLOG.md](BACKLOG.md) |
| 关键取舍及理由 | [DECISIONS.md](DECISIONS.md) |
| 验证计划与已有证据 | [EXPERIMENTS.md](EXPERIMENTS.md) |
| 产品定义、用户、首代范围、商业边界 | [现有 PRD](运营与开发策略/PISCIS_1.0_PRD_2026-10-20.md) |
| 市场假设、竞品与推广资料 | [市场资料索引](市场调查资料/README.md) |
| 系统组成、接口和工程版本入口 | [工程架构](engineering/architecture.md) |
| 跨专业问题示例：机械→电路→固件→软件→证据 | [霍尔键盘演奏链路](engineering/topics/keyboard-chain.md) |
| AI 修改工程的约定 | [AGENTS.md](AGENTS.md) |

沿用现有中文产品、市场和工程目录，不另建重复的 `product/overview.md` 或资料副本。仅新增 `engineering/` 承载整机索引。附件继续引用原位置；出现需要由文档直接维护的小图时再建 `assets/`，不搬入 PCB、CAD、大型模型或生成物。

## 日常使用约定

1. **30 秒记下想法**：在 BACKLOG 的 Later 加一行 `- [ ] 想法或问题` 即可，不必分类、编号或先建文档。只把正在推进的少量项放入 Now。
2. **按用途存放**：Goal / Constraint 放 PRD 或相关专题；Task / Issue 放 BACKLOG；Decision 放 DECISIONS；Experiment / Evidence 放 EXPERIMENTS 或已有报告；Specification / Interface 放对应工程规范或代码。专题只串联这些来源。
3. **只维护一份事实**：BOM、接口、PCB、CAD 各以对应版本的源文件为准，入口见工程架构。任务只写动作与链接，README 只留摘要。新任务统一放 BACKLOG；旧工程任务清单保留其版本语境，通过链接查阅，不抄成第二份状态表。
4. **需要时才标状态**：Confirmed = 在注明条件和版本下已验证；Decided = 已决定但可能未验证；Proposed = 候选；Open = 未确定。文件存在、仿真通过、文件级检查和实物验证应分别描述，不能相互替代。不要求每页添加元数据。
5. **需要时才建正式页**：信息反复使用、跨专业共享、成为模块依赖、需要保存重要理由或复现测试、原页明显难维护时才拆分。一次性草稿留在 BACKLOG 或现有相关文件，无需全部整理。
6. **用链接串起交付**：重要问题从任务连到专题，再连需求、接口、实现及证据；D-xxx / E-xxx 只给决策和实验使用，普通任务不强制编号。默认只维护必要的前向链接。
7. **完成后少量收尾**：任务勾选 `[x]` 留在原分区，积累过多时借助 Git 历史清理；没有第四种任务状态。重大取舍补决策，执行过的验证补条件、结果和证据。接口变化检查直接使用方，失效结论保留原证据并标清适用版本。
8. **保持离线可用**：内部链接使用相对路径；本地资料可离线阅读，外部来源仅作延伸参考。相关变更一起纳入对应 Git 仓库；部分子工程有独立 `.git`，根仓库的提交不能替代子工程版本记录，不自动合并仓库或重建工程。

## F101 实时演奏原型

远程已有的 F101 板端合成、Windows 37 键界面、编译与 RAM 加载脚本保留在 [firmware/MDA_F101实时演奏版](firmware/MDA_F101实时演奏版/说明.md)；开发环境、工具链固定版本和路径前提见该目录说明，既有测试数据见[验证状态](firmware/MDA_F101实时演奏版/验证状态.json)。这些记录仅适用于该原型，本次同步未重新执行硬件测试，也不表示整机或其他工程版本通过验证。

F101 可直接接收 USB MIDI 键盘输入，在板上合成 MDA 电钢琴和 Hammond 风琴，并通过主板耳机口输出。构建方式和实物验证范围见 [F101 独立演奏版](firmware/F101独立演奏版/说明.md)。

## 模块提交与整机版本

新增主机模块：[主机MVP评估板](主机MVP评估板/README.md)、[主机正式PCBA](主机正式PCBA/README.md)。两者已登记为子模块，初始化提交已上传至各自私有 GitHub 仓库，MVP 模块已迁入全志 F101 Beta 与 HPM6360 Beta，并完成迁移前历史归档；不由目录名称推定冻结方案。

已将四个 `Keyboard*` 工程归入一个[霍尔键盘](霍尔键盘/README.md)独立仓库，由根仓库作为单个 Git submodule 管理；[音色模拟](音色模拟/index.html) 同样作为独立子模块管理，远程为私有仓库。历史先固化为[普通文件归档](engineering/archives/keyboard-history-2026-10-23/README.md)，目录迁移已完成，原始 Git 数据完整保留于本机备份区。根仓库记录模块的精确提交，不自动跟随模块 `main`；登记模块不表示选定整机基线。

小模块更新时，只在对应模块提交并推送；根仓库显示模块版本变化可以暂时保留，到大版本集成时再更新指针。例如：

```sh
git -C 霍尔键盘 switch main
git -C 霍尔键盘 add <本次修改的文件>
git -C 霍尔键盘 commit -m "说明模块改动"
git -C 霍尔键盘 push origin main
```

大版本更新时，先确认要纳入的模块提交已推送且工作区干净，再从根目录显式暂存本次选定模块及相关整机文档。以下以 `霍尔键盘` 为例，其余模块按需列出：

```sh
git submodule status
git add 霍尔键盘 README.md DECISIONS.md
git commit -m "记录本次整机版本与模块组合"
git push --recurse-submodules=check origin main
```

需要发布标记时再给已确认的根仓库提交打 tag，版本号由实际发布决定。根提交只保存模块指针，不能保存模块未提交的文件。`--recurse-submodules=check` 用于检查提交是否已存在于模块远程跟踪分支；首次配置完成后仍需实际验证远程可获取。

首次获取整套工程：

```sh
git clone --recurse-submodules git@github.com:The-Cabbage/PISCIS-I_E-Piano-Project.git
```

已有克隆在工作区干净时运行 `git submodule update --init --recursive`，即可检出根提交固定的模块组合；切换根版本后同样执行。该命令通常让模块处于 detached HEAD，继续开发前先在模块内切换到工作分支。不要用 `git submodule update --remote` 复现大版本，它会跟随远程分支而非固定组合。回退或切换前先保存模块未提交改动。

## 何时扩展

| 阶段 | 只在出现实际需求时增加 |
| --- | --- |
| 概念与探索 | 直接使用现有 PRD、调研、BACKLOG、决策；不要求想法全部归档。 |
| 可行性与 MVP | 接口成为依赖时，在对应工程中补正式接口；跨专业问题增多时再加专题。 |
| 工程样机 | 开始多版采购、装配或回归时，明确对应 BOM 的导出规则与版本；对关键需求按需建立 ID 和测试引用，不预建完整追踪矩阵。 |
| 制造与交付 | 真正准备打样/交付时，再增装配说明、测试规范、生产问题及变更记录，绑定实际制造版本。 |

日常维护以推进工程为准，不设强制周报、标签数据库或文档完整性考核。

## KiCad design PISCIS_审阅版_20261024_024835/reports/routing-opt-2026-10-24/before/PISCIS-I_F101.kicad_pcb

Parts:
C1, C2, C4, C6, C9, C11: 10uF; C_1206_3216Metric
C3, C5, C7, C8, C10, C12: 0.1uF; C_0805_2012Metric
C13, C14: 47uF; CP_Elec_5x5.8
J1: Yuzuki_2x20_Female_Socket; Yuzuki_Socket_2x1x20_P2.54mm_Row17.926mm
J2: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical
J3, J4: Conn_01x03_Socket; PinSocket_1x03_P2.54mm_Vertical
J5: SJ1-3523N; AudioJack_SameSky_SJ1-3523N_Horizontal; MPN SJ1-3523N
R1, R2: 10R; R_0805_2012Metric
R3, R4: 4.7k; R_0805_2012Metric
SW1: SKRHADE010; SW-SMD_SKRHADE010; MPN SKRHADE010; LCSC Part C202415
U1: ES8388; QFN-28-1EP_4x4mm_P0.45mm_EP2.6x2.6mm

Connections:
/HP_L_CAND: J5.T, R1.2
/HP_R_CAND: J5.R, R2.2
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.1, C10.1, C11.2, C12.2, J1.39 (H2.19_GND), J2.1, J3.2, J4.2, J5.S, SW1.5, U1.4 (DGND), U1.13 (HPGND), U1.18 (AGND), U1.26 (CE), U1.29 (EPAD)
GPADC: J1.27 (H2.7_GPADC)
unnamed: C13.2, R1.1
unnamed: C14.2, R2.1
unnamed: C2.2, C3.1, U1.19 (ADCVREF)
unnamed: C13.1, U1.12 (LOUT1)
unnamed: C14.1, U1.11 (ROUT1)
unnamed: C4.1, C5.1, U1.20 (VMID)
unnamed: C1.2, U1.10 (VREF)
PB0: J1.31 (H2.11_PB0)
PB1: J1.30 (H2.10_PB1)
PB2: J1.29 (H2.9_PB2), J2.3
PB3: J1.28 (H2.8_PB3), J2.4
PD0: J1.33 (H2.13_PD0), J4.3
PD1: J1.34 (H2.14_PD1), J4.1
PD2: J1.35 (H2.15_PD2)
PD3: J1.36 (H2.16_PD3), J3.3
PD4: J1.37 (H2.17_PD4)
PD5: J1.38 (H2.18_PD5)
PD6: J1.2 (H1.2_PD6), U1.1 (MCLK)
PD7: J1.3 (H1.3_PD7), U1.5 (SCLK)
PD8: J1.4 (H1.4_PD8), U1.7 (LRCK)
PD9: J1.5 (H1.5_PD9), U1.6 (DSDIN)
PD12: J1.6 (H1.6_PD12), SW1.1
PD13: J1.7 (H1.7_PD13), SW1.4
PD14: J1.8 (H1.8_PD14), SW1.3
PD15: J1.9 (H1.9_PD15), SW1.6
PD16: J1.10 (H1.10_PD16), SW1.2
PD17: J1.11 (H1.11_PD17)
PD18: J1.12 (H1.12_PD18)
PD19: J1.13 (H1.13_PD19)
PD20: J1.14 (H1.14_PD20)
PD21: J1.15 (H1.15_PD21)
PD22: J1.32 (H2.12_PD22)
PE0: J1.16 (H1.16_PE0)
PE1: J1.17 (H1.17_PE1)
PE2: J1.18 (H1.18_PE2), R4.2, U1.28 (CCLK)
PE3: J1.19 (H1.19_PE3), R3.2, U1.27 (CDATA)
PE4: J1.20 (H1.20_PE4)
PE5: J1.26 (H2.6_PE5)
PE6: J1.25 (H2.5_PE6)
PE7: J1.24 (H2.4_PE7)
PE8: J1.23 (H2.3_PE8)
PE9: J1.22 (H2.2_PE9)
PE10: J1.21 (H2.1_PE10)
VBUS: J1.40 (H2.20_VBUS)
VCC-3V3: C6.2, C7.2, C8.1, C9.2, C10.2, C11.1, C12.1, J1.1 (H1.1_VCC-3V3), J2.2, J3.1, R3.1, R4.1, U1.2 (DVDD), U1.3 (PVDD), U1.16 (HPVDD), U1.17 (AVDD)

Notes on the sheet:
PIN MAPPING: J1 pads 1..20 = source H1.1..H1.20; pads 21..40 = source H2.1..H2.20.
VBUS is the source-board USB supply rail; VCC-3V3 is its 3.3 V regulator rail.
Generic 1x20 socket: 1.0 mm finished drill, 1.7 mm pad. Confirm purchased socket fit and height.
OLED / TWI2 1:GND 2:3V3 3:SCL(PB2) 4:SDA(PB3)
Assembly: female sockets on carrier F.Cu. Development-board male pins face down.
YUZUKI DEVELOPMENT BOARD - PLUG-IN FEMALE SOCKET
No power isolation or regulation is added here. Module outline / screw holes are drawing guides.
Top view of carrier. USB-C end up; TF-card end down. J1 = two 1x20 sockets.
MT6701 SSI
All 40 contacts are exported as global nets with the original Yuziki_1 signal names.
待确认：四路供电来源；J5 SJ1-3523N 实物安装尺寸；CODEC 控制接口及主控引脚；I2S 引脚复用。
MECHANICAL: pitch 2.54 mm; row centres 17.926 mm; right row top +0.010 mm.
SW1: A=PD12, B=PD13, C=PD14, D=PD15, PRESS=PD16 GPIO input pull-up; pressed=LOW; debounce in firmware.

Board: 2 copper layers, 70.9 x 94.5 mm, 25 parts (0 on the bottom side), 27 nets.

## KiCad design 硬件_先楫半导体HPM6360版本(Beta)/PISCIS-I_HPM6360_Module.kicad_pcb

File 硬件_先楫半导体HPM6360版本(Beta)/README.md:

# PISCIS-I HPM6360 便携式音源模块

本目录是 PISCIS-I 的 HPM6360 硬件工作区。原始 A0 基线保留作参考；新的 **Rev.A 电子乐器评估板** 位于 `hardware/rev_a/`，已经建立分层原理图源、HPM6360 引脚分配、8+8 控制扩展板和 130 mm × 90 mm 六层初始布局。Rev.A 当前是工程验证版本，尚未完成 PCB 布线或投产审核。

## 快速入口

- KiCad 工程：`PISCIS-I_HPM6360_Module.kicad_pro`
- [Rev.A 重构工程](hardware/rev_a/README.md)
- [Rev.A 接口定义](hardware/rev_a/INTERFACES.md)
- [Rev.A HPM6360 Pinmux 表](hardware/rev_a/pinmux.csv)
- [Rev.A 验证状态与投板门槛](hardware/rev_a/VALIDATION.md)
- [系统需求](docs/REQUIREMENTS.md)
- [元器件选型](docs/COMPONENT_SELECTION.md)
- [Rev A0 BOM 工作簿](outputs/01a0a15e-6745-7f52-aa7f-aea0cbdf02fa/PISCIS-I_HPM6360_BOM_RevA0.xlsx)
- [项目级 KiCad 库与 3D 模型清单](hardware/libraries/MODEL_MANIFEST.md)
- [24-Pin POGO 扩展与级联接口](docs/POGO_INTERFACE.md)
- [下一步工作](docs/NEXT_STEPS.md)

## Rev.A 已冻结基线

- 首版是 130 mm × 90 mm、6 层、便于探测和返修的评估板，不再受 65 mm × 65 mm 限制。
- MCU 默认改为 `HPM6360IPA2`，封装为 20 mm × 20 mm、0.5 mm pitch 的 `eLQFP144L`。外围引脚可拖焊返修；底部裸露焊盘仍建议用钢网 + 热台/回流或热风焊接。
- USB-C 固定为 5 V 电源输入；USB-A 固定为 Host，用于 USB MIDI 外设。
- 采用 `W9825G6KH-6I` 32 MiB SDRAM、`GD25Q128ESIGR` QSPI NOR 和 4-bit SDIO microSD。
- `ES8388` 提供立体声耳机输出；单声道 Class-D 通过 JST-PH 接口驱动 4 Ω / 3 W 被动扬声器。
- 独立控制扩展板提供 8 路 10 kΩ 模拟控件和 8 个 A/B 增量编码器，通过 2×8 IDC 短排线连接。
- A0 的电池、双扬声器和 24-pin POGO 架构不进入本次 Rev.A。

## 使用

KiCad 10.0.6 或更高版本直接打开 `PISCIS-I_HPM6360_Module.kicad_pro`。原有自定义库 `PISCIS_Local` 保留；新增的可追溯库快照为 `PISCIS_HPM6360`，位于 `hardware/libraries/footprints/PISCIS_HPM6360.pretty/`，已收集 STEP 位于相邻的 `3dmodels/` 目录。项目私有库为 `PISCIS_Private`，位于 `hardware/libraries/private/`，包含 HPM6360IPA2 145-pin 符号、两种官方图纸派生的 eLQFP144L 中央焊盘候选封装及现有项目资源副本；使用前请阅读该目录的 `README.md`。

在器件订货或打样前，必须完成 [下一步工作](docs/NEXT_STEPS.md) 中的机械布局冻结、电源预算、HPM6360 引脚复用审核和样品可得性确认。

Board: 6 copper layers, 70.0 x 70.0 mm, 78 parts (0 on the bottom side), 43 nets.

Parts:
C1, C2, C23, C24, C37: 22uF; C_1206_3216Metric
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C17, C18, C20, C25, C26, C29, C30, C32, C36, C38, C39: 100nF; C_0603_1608Metric
C15, C16, C31, C40: 4.7uF; C_0603_1608Metric
C19, C21, C33: 1uF; C_0603_1608Metric
C22: 22pF; C_0603_1608Metric
C27, C28: 10uF; C_0805_2012Metric
C34, C35: 12pF; C_0603_1608Metric
D1: SMAJ5.0A; D_SMA
J1: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_GCT_USB4105-xx-A_14P_Compat_TopMnt_Horizon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
L1: 4.7uH; L_Coilcraft_XAL4030-XXX
L2: 2.2uH; L_Coilcraft_XAL4030-XXX
R1, R2, R4: 100k; R_0603_1608Metric
R3: 22.1k; R_0603_1608Metric
R5: 2M; R_0603_1608Metric
R6, R14, R15: 33R; R_0603_1608Metric
R7, R8, R9, R10, R11, R12, R13, R18, R19, R20: 10k; R_0603_1608Metric
R16, R17, R21, R22: 5.1k; R_0603_1608Metric
TP1, TP2, TP3, TP4, TP5: TestPoint_Square; TestPoint_Pad_D1.0mm
U1: HPM6360IPA2; HPM6360IPA2_eLQFP144L_20x20mm_P0.5mm_EP5x5mm
U2: XC6210B332MR; SOT-23-5
U3: SM8082AAAC; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL
U4: CH340E; MSOP-10_3x3mm_P0.5mm
U5: W25Q128JVP; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
USBC1: TYPE-C-31-M-12; USB-C_SMD-TYPE-C-31-M-12_1
X1: X252024MOB4SI; CRYSTAL-SMD_4P-L2.5-W2.0-BL

Connections:
/5V_SYS: C37.1, D1.1 (A1)
/BOOT_0: R9.1, U1.3 (PA20)
/BOOT_1: R8.1, U1.2 (PA21)
/CS0: R19.2, U1.27 (PA00), U5.1 (~CS)
/D0: U1.24 (PA03), U5.5 (DI/IO_{0})
/D1: U1.26 (PA01), U5.2 (DO/IO_{1})
/D2: R18.2, U1.25 (PA02), U5.3 (~WP/IO_{2})
/D3: R20.2, U1.21 (PA05), U5.7 (~HOLD/~RESET/IO_{3})
/DCDC_IN_3V3: C22.2, C23.2, C24.2, C25.2, C26.2, C32.1, C38.1, C39.2, C40.2, L2.1, R1.1, R2.2, R7.2, R11.1, R12.1, R13.1, R18.1, R19.1, R20.1, U1.12 (VIO_01), U1.23 (VIO_00), U1.32 (DCDC_IN), U1.43 (VPMC), U1.46 (VBAT), U1.61 (VIO_02), U1.86 (VIO_02), U1.94 (VIO_01), U1.120 (VIO_01), U1.133 (VIO_01), U4.7 (VCC), U4.10 (V3), U5.8 (VCC)
/DCDC_OUT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C17.1, L1.1, U1.5 (VDD_SOC), U1.18 (VDD_SOC), U1.28 (VDD_SOC), U1.29 (DCDC_SNS), U1.55 (VDD_SOC), U1.68 (VDD_SOC), U1.77 (VDD_SOC), U1.90 (VDD_SOC), U1.104 (VDD_SOC), U1.113 (VDD_SOC), U1.126 (VDD_SOC), U1.140 (VDD_SOC)
/JTAG_TCK: R10.2, TP3.1 (1_1), U1.38 (PY02)
/JTAG_TDI: R13.2, TP4.1 (1_1), U1.40 (PY01)
/JTAG_TDO: TP5.1 (1_1), U1.42 (PY00)
/JTAG_TMS: R11.2, TP2.1 (1_1), U1.37 (PY03)
/JTAG_TRST: R12.2, TP1.1 (1_1), U1.36 (PY04)
/LDO_3V3: C20.1, C21.1, C30.1, C31.1, U1.85 (VREFH), U1.87 (VANA), U2.5 (VOUT)
/MIDI_VBUS: J1.A4, J1.A9, J1.B4, J1.B9, U1.91 (USBVBUS)
/RESET_N: R6.1, R7.1, U1.53 (PZ01)
/SCLK: U1.22 (PA04), U5.6 (CLK)
/UART0_RXD: R15.2, U1.33 (PY07)
/UART0_TXD: R14.1, U1.34 (PY06)
/UART_VBUS: C18.1, C19.1, C27.2, C28.2, C29.2, R4.2, U2.1 (VIN), U3.4 (IN), USBC1.A4B9, USBC1.B4A9
/USB_DM: J1.A7, J1.B7
/USB_DP: J1.A6, J1.B6, U1.92 (USB_DP), U1.93 (USB_DM)
/XTAL_IN: C34.1, R5.2, U1.88 (XTALI), X1.1
/XTAL_OUT: C35.2, R5.1, U1.89 (XTALO), X1.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.1, C36.1, C37.2, C38.2, C39.1, C40.1, D1.2 (A2), J1.A1, J1.A12, J1.B1, J1.B12, J1.SH, R3.1, R8.2, R9.2, R10.1, R16.1, R17.1, R21.1, R22.1, U1.30 (DCDC_GND), U1.84 (VREFL), U1.145 (VSS), U2.2 (GND), U3.2 (GND), U4.3 (GND), U5.4 (GND), U5.9 (EP/GND), USBC1.1, USBC1.2, USBC1.3, USBC1.4, USBC1.A1B12, USBC1.B1A12, X1.2, X1.4
unnamed: C36.2, R6.2
unnamed: J1.A5, R21.2
unnamed: J1.B5, R22.2
unnamed: L1.2, U1.31 (DCDC_LP)
unnamed: C13.2, C15.2, U1.39 (VDD_OTPCAP)
unnamed: C14.1, C16.1, U1.41 (VDD_PMCCAP)
unnamed: C33.1, R1.2, U2.3 (CE)
unnamed: R4.1, U3.1 (EN)
unnamed: C22.1, R2.1, R3.2, U3.5 (FB)
unnamed: L2.2, U3.3 (LX)
unnamed: R14.2, U4.9 (RXD)
unnamed: R15.1, U4.8 (TXD)
unnamed: U4.1 (UD+), USBC1.A6, USBC1.B6
unnamed: U4.2 (UD-), USBC1.A7, USBC1.B7
unnamed: R17.2, USBC1.A5
unnamed: R16.2, USBC1.B5

## KiCad design 全志F101版本(Beta)/Yuziki_1/ProPrj_ProDoc_Board1_2026-09-27_2026-10-14.kicad_pcb

Board: 4 copper layers, 21.0 x 51.0 mm, 60 parts (0 on the bottom side), 78 nets.

Parts:
C1, C2, C3, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C19, C20, C24, C25, C26: C0402-NSK
C4, C5, C6, C18, C21, C22, C23: C0603-NSK
H1, H2: 2.54PHSM-1X20P
L1, L2: IND-SMD_L2.0-W1.6_1
LED1: LED0603 NSK
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15: R0402-NSK
SW1: SW-SMD_4P-L4.2-W3.2-P2.15-LS4.6-1
U1: QFN-68_L7.0-W7.0-P0.35-TL-EP4.5
U2, U3, U4, U5, U6: PAD60
U7, U10: SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U8: SOP-8_L5.2-W5.3-P1.27-LS7.9-BL
U9: TF-SMD_MUP-M617-2
U11: UDFN-4_L1.0-W1.0-P0.65-BL-EP
USB1: USB-C-SMD_TYPE-C-16PIN-2MD-073
X1: osc-smd_4p-l2.0-w1.6-bl

Connections:
$1N145: C19.2, R9.1, U9.4
$1N154: R11.1, U9.10
$1N164: R1.2, U1.42
$1N165: R2.1, U1.47
$1N235: R13.2, USB1.A5
$1N236: R15.2, USB1.B5
$1N238: C18.2, R4.1, R6.2, U7.1
$1N245: R12.1, R14.2, U10.5
$1N246: R5.1, R7.2, U7.5
$1N249: L1.1, U7.3
$1N250: L2.1, U10.3
$1N261: LED1.2, R10.1
AVCC: C14.2, C15.2, U1.56
DXIN: C20.1, U1.58, X1.1
DXOUT: C24.2, U1.59, X1.3
GND: C1.1, C2.1, C3.2, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.2, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, H2.19, LED1.1, R6.1, R7.1, R13.1, R14.1, R15.1, SW1.1, U1.69, U7.2, U8.4, U9.6, U9.9, U9.11, U9.12, U10.2, U11.2, U11.5, USB1.13, USB1.A1B12, USB1.B1A12, X1.2, X1.4
GPADC: H2.7, U1.55
HPOUT: U1.57, U6.1
PA0: U1.53, U3.1
PA1: U1.51, U2.1
PA2: U1.54, U5.1
PA3: U1.52, U4.1
PB0: H2.11, U1.67, USB1.B8
PB1: H2.10, U1.66, USB1.A8
PB2: H2.9, U1.65
PB3: H2.8, U1.64
PD0: H2.13, U1.2
PD1: H2.14, U1.3
PD2: H2.15, U1.4
PD3: H2.16, U1.5
PD4: H2.17, U1.6
PD5: H2.18, U1.7
PD6: H1.2, U1.8
PD7: H1.3, U1.9
PD8: H1.4, U1.10
PD9: H1.5, U1.11
PD12: H1.6, U1.12
PD13: H1.7, U1.13
PD14: H1.8, U1.14
PD15: H1.9, U1.15
PD16: H1.10, U1.16
PD17: H1.11, U1.17
PD18: H1.12, U1.20
PD19: H1.13, U1.21
PD20: H1.14, U1.22
PD21: H1.15, U1.23
PD22: H2.12, U1.1
PE0: H1.16, U1.24
PE1: H1.17, U1.25
PE2: H1.18, U1.26
PE3: H1.19, U1.27
PE4: H1.20, U1.28
PE5: H2.6, U1.29
PE6: H2.5, U1.30
PE7: H2.4, U1.31
PE8: H2.3, U1.32
PE9: H2.2, U1.33
PE10: H2.1, U1.34
SDC0_CLK: R2.2, U9.5
SDC0_CMD: U1.48, U9.3
SDC0_D0: U1.46, U9.7
SDC0_D1: U1.45, U9.8
SDC0_D2: U1.50, U9.1
SDC0_D3: U1.49, U9.2
SDC0_DC: R11.2, U1.44
SPI0-CLK: R1.1, U8.6
SPI0-CS0: SW1.4, U1.41, U8.1
SPI0-HOLD: R8.2, U1.37, U8.7
SPI0-MISO: U1.40, U8.2
SPI0-MOSI: U1.38, U8.5
SPI0-WP: R3.1, U1.39, U8.3
USB-DM: U1.60, USB1.A7, USB1.B7
USB-DP: U1.61, USB1.A6, USB1.B6
VBUS: C4.2, C5.2, C21.2, C22.2, H2.20, U7.4, U10.1, U10.4, USB1.A4B9, USB1.B4A9
VCC-1V8: C8.2, C13.2, U1.18, U1.63
VCC-3V3: C1.2, C2.2, C3.1, C16.2, C17.2, C23.2, C26.2, H1.1, L2.2, R3.2, R4.2, R8.1, R9.2, R10.2, R12.2, U1.19, U1.43, U1.62, U8.8, U11.3, U11.4
VCC-PSRAM: C7.2, C25.2, U1.35, U11.1
VDD-SYS: C6.2, C9.2, C10.2, C11.2, C12.2, L1.2, R5.2, U1.36, U1.68
